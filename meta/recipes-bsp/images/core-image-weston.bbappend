IMAGE_INSTALL_append = " \
                       i2c-tools \
                       ethtool \
                       iw \
                       wpa-supplicant \
                       kernel-modules \
                       gst-examples \
                       gstreamer1.0-plugins-nvvideosinks \
                       gstreamer1.0-plugins-nvvidconv \
                       "

